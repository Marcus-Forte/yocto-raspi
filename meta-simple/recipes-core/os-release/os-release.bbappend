OS_RELEASE_FIELDS:append = " COMMIT_HASH"

COMMIT_HASH = "MYHASH"