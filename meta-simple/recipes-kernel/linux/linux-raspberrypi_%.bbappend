FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://serial.cfg"