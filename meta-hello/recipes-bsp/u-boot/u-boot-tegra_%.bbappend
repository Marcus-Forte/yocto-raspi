UBOOT_EXTLINUX_ROOT = "${cbootargs} root=/dev/mmcblk0p1"
UBOOT_EXTLINUX_KERNEL_ARGS = "rw rootwait ${bootargs}"
